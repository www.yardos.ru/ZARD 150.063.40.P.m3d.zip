# KOMPAS-3D part (ZARD 150.063.40.P.m3d)

Model tree:
1. Булева операция:2
